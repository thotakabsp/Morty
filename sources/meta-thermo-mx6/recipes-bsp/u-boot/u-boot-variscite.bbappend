FILESEXTRAPATHS_append := "${THISDIR}/patches:"

SRC_URI += "	\
		file://0001-Morty-base.patch	\
"
SRCREV="cd1971cf177e97282a922d85046f83a2e706e306"
